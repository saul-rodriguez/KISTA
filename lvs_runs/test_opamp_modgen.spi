* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                              *
*                                                           *
* Cell Name  : test_opamp_modgen                            *
* Netlisted  : Thu Nov 25 07:40:07 2021                     *
* PVS Version: 16.15-s010 Fri Jun 28 22:24:07 PDT 2019      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MN(nmos3) _nmos1v _soi_nd(D) poly_conn(G) _soi_nsb(S) _soi_nsb(B)
*.DEVTMPLT 1 MP(pmos3) _pmos1v _soi_pd(D) poly_conn(G) _soi_psb(S) _soi_psb(B)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nmos3_CDNS_9                                    *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nmos3_CDNS_9 2 3 4
** N=4 EP=3 FDC=1
M0 2 3 4 4 nmos3 L=2e-06 W=1e-05 AD=2.5e-11 AS=0 PD=2.5e-05 PS=0 fw=1e-05 sa=2e-06 sb=2e-06 $X=7000 $Y=2000 $dt=0
.ends nmos3_CDNS_9

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: nmos3_CDNS_10                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt nmos3_CDNS_10 2 3 4
** N=4 EP=3 FDC=1
M0 2 3 4 4 nmos3 L=1e-06 W=8e-06 AD=2e-11 AS=0 PD=2.1e-05 PS=0 fw=8e-06 sa=2e-06 sb=2e-06 $X=7000 $Y=2000 $dt=0
.ends nmos3_CDNS_10

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: pmos3_CDNS_11                                   *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt pmos3_CDNS_11 2 3 4
** N=5 EP=3 FDC=1
M0 2 3 4 4 pmos3 L=1e-06 W=6e-06 AD=1.5e-11 AS=0 PD=1.7e-05 PS=0 fw=6e-06 sa=2e-06 sb=2e-06 $X=7000 $Y=2000 $dt=1
.ends pmos3_CDNS_11

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: test_opamp_modgen                               *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt test_opamp_modgen BIAS INN INP OUT VD VS
** N=10 EP=6 FDC=50
X182 6 INP 3 nmos3_CDNS_9 $T=34220 154800 0 0 $X=34220 $Y=154800
X183 OUT INN 3 nmos3_CDNS_9 $T=34220 234800 1 0 $X=34220 $Y=204800
X184 OUT INN 3 nmos3_CDNS_9 $T=52460 154800 0 0 $X=52460 $Y=154800
X185 6 INP 3 nmos3_CDNS_9 $T=52460 234800 1 0 $X=52460 $Y=204800
X186 6 INP 3 nmos3_CDNS_9 $T=70700 154800 0 0 $X=70700 $Y=154800
X187 OUT INN 3 nmos3_CDNS_9 $T=70700 234800 1 0 $X=70700 $Y=204800
X188 OUT INN 3 nmos3_CDNS_9 $T=88940 154800 0 0 $X=88940 $Y=154800
X189 6 INP 3 nmos3_CDNS_9 $T=88940 234800 1 0 $X=88940 $Y=204800
X190 6 INP 3 nmos3_CDNS_9 $T=107180 154800 0 0 $X=107180 $Y=154800
X191 OUT INN 3 nmos3_CDNS_9 $T=107180 234800 1 0 $X=107180 $Y=204800
X192 OUT INN 3 nmos3_CDNS_9 $T=125420 154800 0 0 $X=125420 $Y=154800
X193 6 INP 3 nmos3_CDNS_9 $T=125420 234800 1 0 $X=125420 $Y=204800
X194 6 INP 3 nmos3_CDNS_9 $T=143660 154800 0 0 $X=143660 $Y=154800
X195 OUT INN 3 nmos3_CDNS_9 $T=143660 234800 1 0 $X=143660 $Y=204800
X196 OUT INN 3 nmos3_CDNS_9 $T=161900 154800 0 0 $X=161900 $Y=154800
X197 6 INP 3 nmos3_CDNS_9 $T=161900 234800 1 0 $X=161900 $Y=204800
X198 6 INP 3 nmos3_CDNS_9 $T=180140 154800 0 0 $X=180140 $Y=154800
X199 OUT INN 3 nmos3_CDNS_9 $T=180140 234800 1 0 $X=180140 $Y=204800
X200 OUT INN 3 nmos3_CDNS_9 $T=198380 154800 0 0 $X=198380 $Y=154800
X201 6 INP 3 nmos3_CDNS_9 $T=198380 234800 1 0 $X=198380 $Y=204800
X202 3 BIAS VS nmos3_CDNS_10 $T=68620 34600 0 0 $X=68620 $Y=34600
X203 3 BIAS VS nmos3_CDNS_10 $T=68620 102600 1 0 $X=68620 $Y=76600
X204 3 BIAS VS nmos3_CDNS_10 $T=84860 34600 0 0 $X=84860 $Y=34600
X205 3 BIAS VS nmos3_CDNS_10 $T=84860 102600 1 0 $X=84860 $Y=76600
X206 BIAS BIAS VS nmos3_CDNS_10 $T=101100 34600 0 0 $X=101100 $Y=34600
X207 BIAS BIAS VS nmos3_CDNS_10 $T=101100 102600 1 0 $X=101100 $Y=76600
X208 3 BIAS VS nmos3_CDNS_10 $T=117340 34600 0 0 $X=117340 $Y=34600
X209 3 BIAS VS nmos3_CDNS_10 $T=117340 102600 1 0 $X=117340 $Y=76600
X210 3 BIAS VS nmos3_CDNS_10 $T=133580 34600 0 0 $X=133580 $Y=34600
X211 3 BIAS VS nmos3_CDNS_10 $T=133580 102600 1 0 $X=133580 $Y=76600
X212 OUT 6 VD pmos3_CDNS_11 $T=279500 62800 0 0 $X=279500 $Y=62800
X213 6 6 VD pmos3_CDNS_11 $T=279500 120800 0 0 $X=279500 $Y=120800
X214 OUT 6 VD pmos3_CDNS_11 $T=279500 178800 0 0 $X=279500 $Y=178800
X215 6 6 VD pmos3_CDNS_11 $T=279500 236800 0 0 $X=279500 $Y=236800
X216 6 6 VD pmos3_CDNS_11 $T=295900 62800 0 0 $X=295900 $Y=62800
X217 OUT 6 VD pmos3_CDNS_11 $T=295900 120800 0 0 $X=295900 $Y=120800
X218 6 6 VD pmos3_CDNS_11 $T=295900 178800 0 0 $X=295900 $Y=178800
X219 OUT 6 VD pmos3_CDNS_11 $T=295900 236800 0 0 $X=295900 $Y=236800
X220 OUT 6 VD pmos3_CDNS_11 $T=312300 62800 0 0 $X=312300 $Y=62800
X221 6 6 VD pmos3_CDNS_11 $T=312300 120800 0 0 $X=312300 $Y=120800
X222 OUT 6 VD pmos3_CDNS_11 $T=312300 178800 0 0 $X=312300 $Y=178800
X223 6 6 VD pmos3_CDNS_11 $T=312300 236800 0 0 $X=312300 $Y=236800
X224 6 6 VD pmos3_CDNS_11 $T=328700 62800 0 0 $X=328700 $Y=62800
X225 OUT 6 VD pmos3_CDNS_11 $T=328700 120800 0 0 $X=328700 $Y=120800
X226 6 6 VD pmos3_CDNS_11 $T=328700 178800 0 0 $X=328700 $Y=178800
X227 OUT 6 VD pmos3_CDNS_11 $T=328700 236800 0 0 $X=328700 $Y=236800
X228 OUT 6 VD pmos3_CDNS_11 $T=345100 62800 0 0 $X=345100 $Y=62800
X229 6 6 VD pmos3_CDNS_11 $T=345100 120800 0 0 $X=345100 $Y=120800
X230 OUT 6 VD pmos3_CDNS_11 $T=345100 178800 0 0 $X=345100 $Y=178800
X231 6 6 VD pmos3_CDNS_11 $T=345100 236800 0 0 $X=345100 $Y=236800
.ends test_opamp_modgen
