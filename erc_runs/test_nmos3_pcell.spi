* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* CDL Netlist:                                              *
*                                                           *
* Cell Name  : test_nmos3_pcell                             *
* Netlisted  : Tue Oct 26 10:36:54 2021                     *
* PVS Version: 16.15-s010 Fri Jun 28 22:24:07 PDT 2019      *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
*.LDD
*.DEVTMPLT 0 MN(nmos3) _nmos1v _soi_nd(D) poly_conn(G) _soi_nsb(S) _soi_nsb(B)
*.DEVTMPLT 1 MP(pmos3) _pmos1v _soi_pd(D) poly_conn(G) _soi_psb(S) _soi_psb(B)

* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
* Sub cell: test_nmos3_pcell                                *
* +++++++++++++++++++++++++++++++++++++++++++++++++++++++++ *
.subckt test_nmos3_pcell
** N=4 EP=0 FDC=1
M0 2 3 1 1 nmos3 L=1e-06 W=1.2e-05 AD=3e-11 AS=0 PD=2.9e-05 PS=0 fw=1.2e-05 sa=2e-06 sb=2e-06 $X=12000 $Y=4200 $dt=0
.ends test_nmos3_pcell
